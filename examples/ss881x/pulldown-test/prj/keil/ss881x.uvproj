# Keil uVision project ss881x.uvproj, settings and files
target Target (MCS-51)
  device: SS881X SinhMicro
  cpu: IRAM(0-0xBF) IROM(0-0x1FFF) CLOCK(12000000)
  output: ss881x +hex
  AfterMake: C:\Keil_v5\C51\BIN\ihex2bin.exe -i Objects\ss881x.hex -o Output\ss881x.bin
  AfterMake: C:\Keil_v5\C51\BIN\binEncrypt.exe Output\ss881x.bin Output\ss881x_fw.bin 0x53383058
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\inc;..\..\prj
  link misc: REMOVEUNUSED
  group Src
    ../../src/: main.c
