# Keil uVision project ss888x.uvproj, settings and files
target Target 1 (MCS-51)
  device: SS888X SinhMicro
  cpu: IRAM(0-0xFF) XRAM(0x8000-0x833F) IROM(0-0x3FFF) CLOCK(12000000)
  output: ss888x +hex
  AfterMake: C:\Keil_v5\C51\BIN\ihex2bin.exe -i Objects\ss888x.hex -o Output\ss888x.bin
  AfterMake: C:\Keil_v5\C51\BIN\binEncrypt.exe Output\ss888x.bin Output\ss888x_fw.bin 0x53383058
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\include
  group Source Group 1
    ./: START_SS888X.A51
    ../../src/: main.c
