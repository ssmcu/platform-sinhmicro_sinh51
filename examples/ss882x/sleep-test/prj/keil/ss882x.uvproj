# Keil uVision project ss882x.uvproj, settings and files
target Target (MCS-51)
  device: SS882X SinhMicro
  cpu: IRAM(0-0x3F) IROM(0-0x3EF) CLOCK(6000000)
  output: ss882x +hex
  AfterMake: C:\Keil_v5\C51\BIN\ihex2bin.exe -i Objects\ss882x.hex -o Output\ss882x.bin
  AfterMake: C:\Keil_v5\C51\BIN\binEncrypt.exe Output\ss882x.bin Output\ss882x_fw.bin 0x53383058
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\inc;..\..\prj
  link misc: REMOVEUNUSED
  group Src
    ../../src/: main.c
    ./: START_SS882X.A51
